# Keil uVision project os.uvprojx, settings and files
target kernel (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: os
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\cortex-m3\include;E:\os_cook;..\cortex-m3\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group cortex-m3
    ../cortex-m3/: port.c systick.c startup.s intr.s
    ../cortex-m3/bsp/: stm32f10_Init.c stm32f10_serial.c
  group src
    ../: task.c mem.c ipc.c
  group main
    ./: main.c
target test (6190000::V6.19::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: os
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\cortex-m3\include;E:\os_cook
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
